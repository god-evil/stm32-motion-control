# Keil uVision project STM32F4.uvprojx, settings and files
target KrBoard (ARM-ADS)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: BGG1000 +hex
  c flags: Optim=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ..\BSP;..\App;..\FWLib\STM32F4xx_HAL_Driver\Inc\Legacy;..\FWLib\CMSIS\Device\ST\STM32F4xx\Include;..\FWLib\CMSIS\Include;..\FWLib\STM32F4xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8020000 size 0x80000
  memory RVCT9: RAM 0x2000c000 size 0xb000
  link misc: --diag_suppress=L6314
--diag_suppress=L6305W
  group App
    ../App/: StartUp.s App.c
software components: CMSIS:CORE 4.1.0
